# Keil uVision project BLE_Beacon.uvprojx, settings and files
target Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_Beacon +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_Beacon.axf --output Release\Objects\BLE_Beacon.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_ASSERT HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH STEVAL_IDB007V1
  c include: ..\..\inc;..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\hal\inc;..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc;..\..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\..\Library\Bluetooth_LE\OTA\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG1.sct
  group BlueNRG1_Periph_Driver
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_pka.c
  group Platforms_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c LPS25HB.c LSM6DS3.c SDK_EVAL_SPI.c SDK_EVAL_I2C.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BlueNRG1_it.c BLE_Beacon_main.c myADC.c mylsm6d.c
  group Hal
    ../../../../../Library/hal/src/: osal.c sleep.c context_switch.s clock.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
